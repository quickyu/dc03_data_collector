# Keil uVision project DC03_data_collector.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DC03_data_collector +hex
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: .\src\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ./src/lib/: core_cm3.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c system_stm32f10x.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_crc.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_iwdg.c
  group src
    ./src/: main.c RTX_Conf.c startup_stm32f10x_md.s Retarget.c serial.c led_digital.c init_periph.c save_count.c comm.c ticktack.c ir_decode.c remote_control.c
